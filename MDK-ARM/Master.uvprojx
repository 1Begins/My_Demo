# Keil uVision project Master.uvprojx, settings and files
target Master (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Master +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\IMCALib\Task; ..\IMCALib\Tool; ..\IMCALib\Module; ..\IMCALib\Module\USMART; ..\IMCALib\Tool\PC_connection; ..\IMCALib\Tool\judge-driver; ..\IMCALib\Module\DSP; ..\IMCALib\Module\DSP\Include; ..\IMCALib\Module\IMU_IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Task
    ../IMCALib/Task/: Chassis_Task.c Gimbal_Task.c Jscope_Task.c pid.c RC_Task.c CanBus_Task.c Limit_Switch.c ControlTask.c
  group Tool
    ../IMCALib/Tool/: PrintfInfo.c mytype.h ramp.c Vision_interact.c user_lib.c Ano_Dt.c
    ../IMCALib/Tool/PC_connection/: Judge_interact.c
    ../IMCALib/Tool/judge-driver/: Driver_Judge.c
  group Module
    ../IMCALib/Module/USMART/: APPInteraction.c usmart.c usmart_config.c usmart_str.c
    ../IMCALib/Module/DSP/: arm_cortexM4lf_math.lib
    ../IMCALib/Module/IMU_IIC/: IMU_Task.c IOI2C.c
software components: CMSIS:CORE 4.3.0
